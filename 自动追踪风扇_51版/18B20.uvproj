# Keil uVision project 18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\CODE\DS18B20;.\CODE\LCD12864;.\CODE\UART
  group Source Group 1
    ./: main.c
    ./CODE/LCD12864/: LCD12864.c
    ./CODE/DS18B20/: DS18B20.c
