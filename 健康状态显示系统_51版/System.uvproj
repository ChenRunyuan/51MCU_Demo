# Keil uVision project System.uvproj, settings and files
target System (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: System +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code\LCD12864;.\Code\UART
  group USER
    ./: main.c
  group CODE
    ./Code/LCD12864/: LCD12864.c
    ./Code/UART/: uart.c
